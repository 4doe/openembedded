require linux-tmtwin-3.1.1.inc

MACHINE_KERNEL_PR_append = ".8"

